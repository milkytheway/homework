# Keil uVision project AHT21-Test.uvprojx, settings and files
target AHT21-Test (5060960::V5.06 update 7 (build 960)::.\ARM-COMPILER-506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AHT21-Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/IIC;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/RTT;../Middlewares/easylogger/inc;../Bsp/AHT21/driver;../Bsp/AHT21/handler;../Bsp/MPU6050/driver;../Bsp/MPU6050/test;..\Bsp\MPU6050\handler;..\Bsp\driver_resource;..\Adaptation
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Middlewares/IIC/: iic_hal.c
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Bsp/AHT21
    ../Bsp/AHT21/driver/: ec_bsp_aht21_driver.c
    ../Bsp/AHT21/handler/: ec_bsp_temp_humi_handler.c
    ../Bsp/driver_resource/: driver_resource.h
  group Bsp/MPUxxx
    ../Bsp/MPU6050/driver/: bsp_mpuxxxx_driver.c
    ../Bsp/MPU6050/test/: test_mpu6050_driver.c
    ../Bsp/MPU6050/handler/: bsp_mpuxxxx_handler.c
    ../Bsp/driver_resource/: driver_resource.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/easy_logger
    ../Middlewares/easylogger/port/: elog_port.c
    ../Middlewares/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares/easylogger/inc/: elog_cfg.h
  group System
    ../Adaptation/: AHT21_adapter.c MPU6050_adapter.c
software components: CMSIS:CORE 4.3.0
